# IAR project spi_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; HSE_VALUE=25000000; USE_USB_OTG_FS; malloc=pvPortMalloc; free=vPortFree
  ICCARM.CCIncludePath2: $PROJ_DIR$; src\; inc\; ..\lib\CMSIS-F4\Include; ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\freertos-7.5.2\include; ..\lib\freertos-7.5.2\portable\IAR\ARM_CM4F; ..\lib\drivers; ..\lib\protobuf
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc
  OBJCOPY.OOCOutputFile: spi_master.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group FreeRTOS
    ../lib/freertos-7.5.2/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../lib/freertos-7.5.2/portable/MemMang/: heap_4.c
    ../lib/freertos-7.5.2/portable/IAR/ARM_CM4F/: port.c portasm.s
  group PeriphLib
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./: startup_stm32f4xx.s
  group SPI
    ../lib/drivers/: pin.c pin.h spi.c spi.h
  group User/inc
    inc/: app_imu.h app_rcv_data.h dev_imu.h dev_spi.h FreeRTOSConfig.h lwipopts.h main.h netconf.h stm32f4x7_eth.h stm32f4x7_eth_bsp.h stm32f4x7_eth_conf.h stm32f4xx_conf.h stm32f4xx_it.h
  group User/src
    src/: app_imu.c dev_imu.c dev_spi.c main.c stm32f4x7_eth.c stm32f4x7_eth_bsp.c stm32f4xx_it.c system_stm32f4xx.c
